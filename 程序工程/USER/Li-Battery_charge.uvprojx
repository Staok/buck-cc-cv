# Keil uVision project Li-Battery_charge.uvprojx, settings and files
target Li-Battery_charge (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Li-Battery_charge +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\DS18B20;..\HARDWARE\SYS_IO;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\Self Checking;..\HARDWARE\ADC;..\HARDWARE\ITEMP;..\HARDWARE\LCD;..\HARDWARE\GUI_MENU;..\HARDWARE\SYS_INF_CTRL;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: Li-Battery_charge.c system_stm32f10x.c stm32f10x_it.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SYS_IO/: sys_io.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/Self Checking/: SelfChecking.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ITEMP/: tsensor.c
    ../HARDWARE/LCD/: GUI.c lcd.c
    ../HARDWARE/GUI_MENU/: MENU.c
    ../HARDWARE/SYS_INF_CTRL/: SYS_INF_CTRL.c
